## examples/Esp32-ESP-IDF/component_smoke/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000
# CONFIG_AUTOSTART_ARDUINO is not set
CONFIG_MBEDTLS_PSK_MODES=y
CONFIG_MBEDTLS_KEY_EXCHANGE_PSK=y
```
